# Keil uVision project GRBL.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GRBL +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: coolant_control.c eeprom.c gcode.c limits.c main.c motion_control.c nuts_bolts.c planner.c print.c protocol.c report.c serial.c settings.c spindle_control.c stepper.c system.c probe.c
  group Startup
    ./include/TI/Startup/: startup_TM4C123.s system_TM4C123.c system_TM4C123.h
